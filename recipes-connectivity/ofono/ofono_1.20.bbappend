RDEPENDS_${PN}-tests_remove = "python3-pygobject"
