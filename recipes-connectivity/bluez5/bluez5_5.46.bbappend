RDEPENDS_${PN}-testtools_remove = "python3-pygobject"
