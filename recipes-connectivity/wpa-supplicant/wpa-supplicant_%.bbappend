DEPENDS_append = " libgcrypt"

PREFERRED_VERSION_libgcrypt = "1.7.3"
