require core-image-renesas-base.inc
require core-image-bsp.inc
require core-image-weston.inc
require core-image-docker.inc
