require core-image-renesas-base.inc
